# Keil uVision project BLDC_Driver_ARM.uvprojx, settings and files
target Control_BLDC (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: BLDC_Driver_ARM +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,HSE_VALUE = 8000000
  c include: ..\BLDC_Driver_ARM_non_cont_update;.\CMSIS;.\Startup;.\STM32F10x_StdPeriph_Driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ./: main.c User_PWM.c User_HALLSensor.c User_CAN.c User_ResetHardfault.c User_Algorithm.c filter.c matrix.c User_ADC.c User_Delay.c User_Encoder.c User_Brake.c User_LED.c User_Filter.c
  group CMSIS
    ./CMSIS/: core_cm3.c stm32f10x_it.c
  group StdPeriph
    ./STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_can.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_tim.c stm32f10x_wwdg.c stm32f10x_adc.c stm32f10x_flash.c
software components: CMSIS:CORE 5.1.1, Device:Startup 1.0.0
